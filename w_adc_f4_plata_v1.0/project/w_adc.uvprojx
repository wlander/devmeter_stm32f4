# Keil uVision project w_adc.uvprojx, settings and files
target w_adc_project (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: w_adc +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\Project;..\..\CMSIS;..\..\SPL;..\main;..\..\SDIO_SD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f4xx.s
  group CMSIS
    ../../CMSIS/: system_stm32f4xx.c core_cm4.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group SPL
    ../../SPL/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c misc.c stm32f4xx_usart.c
  group Main
    ../main/: main.c conf_init.c adc_module_def.h
  group Flash
    ../../SDIO_SD/: stm32f4_discovery_sdio_sd.c stm32f4xx_sdio.c sd_streamer.c sd_stream_cntrl.c
